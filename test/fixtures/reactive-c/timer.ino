// timer: a Mealy machine, generated by Silinx from the ASM chart timer.asm.json (edit the drawing, not this file).
// One tick every TICK_MS milliseconds: the inputs read once at its start, the outputs written to their pins at its end
// (Silinx's synchronous reactive model: docs/SYSTEMS.md).
// Inputs: start D2, tick D3, secs D4 D5 D6 D7.
// Outputs: done D8, left D9 D10 D11 D12.
// (a port of several bits: its pins bit 0 first)

#include <Arduino.h>

// ---- the pins
const uint8_t PIN_START = 2;
const uint8_t PIN_TICK = 3;
const uint8_t PIN_SECS[4] = { 4, 5, 6, 7 };
const uint8_t PIN_DONE = 8;
const uint8_t PIN_LEFT[4] = { 9, 10, 11, 12 };

const unsigned long TICK_MS = 10;   // the tick's period

// ---- the states
enum State { S_IDLE, S_COUNT };

// ---- the inputs, read once per tick
static uint8_t start;
static uint8_t tick;
static uint8_t secs;   // 4 bits

// ---- the outputs
static uint8_t done;
static uint8_t left;   // 4 bits

// ---- the memory
static enum State state;
static uint8_t cnt;   // 4 bits

// a number from its pins, bit 0 first
static uint32_t readBits(const uint8_t *pins, uint8_t n) {
  uint32_t v = 0;
  for (uint8_t i = 0; i < n; i++) if (digitalRead(pins[i]) == HIGH) v |= (uint32_t)1 << i;
  return v;
}

// a number to its pins, bit 0 first
static void writeBits(const uint8_t *pins, uint8_t n, uint32_t v) {
  for (uint8_t i = 0; i < n; i++) digitalWrite(pins[i], (v >> i) & 1 ? HIGH : LOW);
}

static void readInputs(void) {
  start = digitalRead(PIN_START) == HIGH;
  tick = digitalRead(PIN_TICK) == HIGH;
  secs = readBits(PIN_SECS, 4);
}

static void writeOutputs(void) {
  digitalWrite(PIN_DONE, done ? HIGH : LOW);
  writeBits(PIN_LEFT, 4, left);
}

// the reset state
static void resetMachine(void) {
  state = S_IDLE;
  cnt = 0;
}

// one tick: the outputs of the present state and of the inputs, then the next state
static void stepMachine(void) {
  readInputs();
  // the outputs' defaults
  done = 0;
  left = 0;
  switch (state) {
    case S_IDLE:
      if (start) {
        cnt = 0;
        state = S_COUNT;
      }
      break;
    case S_COUNT:
      left = (secs - cnt) & 0xF;
      if (tick) {
        if (cnt == (uint32_t)secs - 1) {
          done = 1;
          state = S_IDLE;
        } else {
          cnt = (cnt + 1) & 0xF;
        }
      }
      break;
  }
  writeOutputs();
}

void setup() {
  pinMode(PIN_START, INPUT);
  pinMode(PIN_TICK, INPUT);
  for (uint8_t i = 0; i < 4; i++) pinMode(PIN_SECS[i], INPUT);
  pinMode(PIN_DONE, OUTPUT);
  for (uint8_t i = 0; i < 4; i++) pinMode(PIN_LEFT[i], OUTPUT);
  resetMachine();
}

void loop() {
  static unsigned long lastTick = 0;
  if (millis() - lastTick < TICK_MS) return;
  lastTick += TICK_MS;
  stepMachine();
}
